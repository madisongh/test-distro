PACKAGECONFIG_append = " libv4l2"
