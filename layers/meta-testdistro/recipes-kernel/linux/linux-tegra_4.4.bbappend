export KCFLAGS = "-Wno-error=format-truncation -Wno-error=format-overflow \
                  -Wno-error=duplicate-decl-specifier -Wno-error=int-in-bool-context"
