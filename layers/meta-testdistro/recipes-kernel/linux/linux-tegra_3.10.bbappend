SRCREV = "${AUTOREV}"
KCFLAGS_tegra124 = "-Wno-error=parentheses -Wno-error=maybe-uninitialized"
