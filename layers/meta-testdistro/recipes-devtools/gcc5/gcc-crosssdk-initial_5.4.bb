require recipes-devtools/gcc5/gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc

