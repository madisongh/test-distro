require recipes-devtools/gcc5/gcc-cross_${PV}.bb
require gcc-crosssdk.inc
