require recipes-devtools/gcc5/gcc-${PV}.inc
require libgcc.inc
