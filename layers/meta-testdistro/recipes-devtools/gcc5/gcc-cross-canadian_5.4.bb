require recipes-devtools/gcc5/gcc-${PV}.inc
require gcc-cross-canadian.inc



