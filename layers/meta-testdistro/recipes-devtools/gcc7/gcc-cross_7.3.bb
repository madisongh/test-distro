require recipes-devtools/gcc7/gcc-${PV}.inc
require gcc-cross.inc

