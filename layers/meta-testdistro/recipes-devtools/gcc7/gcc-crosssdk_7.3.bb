require recipes-devtools/gcc7/gcc-cross_${PV}.bb
require gcc-crosssdk.inc
