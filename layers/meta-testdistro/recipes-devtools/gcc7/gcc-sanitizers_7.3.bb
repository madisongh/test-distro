require recipes-devtools/gcc7/gcc-${PV}.inc
require recipes-devtools/gcc/gcc-sanitizers.inc
