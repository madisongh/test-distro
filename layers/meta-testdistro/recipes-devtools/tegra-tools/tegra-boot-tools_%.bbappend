EXTRA_OECONF_append_jetson-tx2-cboot = " --with-extended-sector-count=511"
PACKAGE_ARCH_jetson-tx2-cboot = "${MACHINE_ARCH}"
