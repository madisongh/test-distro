require go-1.10-patches.inc
