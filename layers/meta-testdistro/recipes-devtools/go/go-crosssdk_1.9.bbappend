require go-srcappend.inc
