FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-dep_test-symlink-to-dep-instead-of-rebuilding.patch"
