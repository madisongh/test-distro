require go-1.11-patches.inc
