FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-Fix-environment-detect_cuda_compiler-method.patch"

