TESTCASE = "4 shared"
require cuda-meson-tests.inc
