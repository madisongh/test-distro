TESTCASE = "12 cuda dependency (mixed)"
require cuda-meson-tests.inc
