TESTCASE = "6 std"
require cuda-meson-tests.inc
