TESTCASE = "11 cuda dependency (nvcc)"
require cuda-meson-tests.inc
