TESTCASE = "8 release"
require cuda-meson-tests.inc
