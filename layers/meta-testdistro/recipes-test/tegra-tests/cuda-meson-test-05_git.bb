TESTCASE = "5 threads"
require cuda-meson-tests.inc
