TESTCASE = "10 cuda dependency"
require cuda-meson-tests.inc
