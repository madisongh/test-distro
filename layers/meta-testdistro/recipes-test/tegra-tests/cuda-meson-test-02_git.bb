TESTCASE = "2 split"
require cuda-meson-tests.inc
