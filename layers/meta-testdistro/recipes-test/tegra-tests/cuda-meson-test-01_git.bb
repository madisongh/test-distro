TESTCASE = "1 simple"
require cuda-meson-tests.inc
