TESTCASE = "3 cudamodule"
require cuda-meson-tests.inc
