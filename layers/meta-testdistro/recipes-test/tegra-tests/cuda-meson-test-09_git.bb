TESTCASE = "9 optimize for space"
require cuda-meson-tests.inc
