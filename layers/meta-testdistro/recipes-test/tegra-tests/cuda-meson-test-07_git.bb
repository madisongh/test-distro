TESTCASE = "7 static vs runtime"
require cuda-meson-tests.inc
