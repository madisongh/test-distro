RDEPENDS_${PN} += "\
    golang-runtime \
    golang-runtime-dev \
"
