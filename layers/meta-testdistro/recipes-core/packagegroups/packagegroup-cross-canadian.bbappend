RDEPENDS_${PN} += "go-cross-canadian-${TRANSLATED_TARGET_ARCH}"
