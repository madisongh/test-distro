RDEPENDS_${PN} += "nativesdk-go"
RDEPENDS_${PN} += "nativesdk-go-runtime"
RDEPENDS_${PN} += "nativesdk-go-runtime-dev"
RDEPENDS_${PN} += "nativesdk-go-runtime-staticdev"
