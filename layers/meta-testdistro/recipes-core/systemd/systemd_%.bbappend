FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-network-drop-invalid-assertion.patch file://0002-network-fix-assertion-when-link-get-carrier.patch"

