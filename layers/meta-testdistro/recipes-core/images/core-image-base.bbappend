IMAGE_INSTALL += "packagegroup-golang"
