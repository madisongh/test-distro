require syslog-ng.inc

SRC_URI[md5sum] = "6928e9be3499a2e9ae52ea8aa204b165"
SRC_URI[sha256sum] = "ef47fada52981e09af570457a5af30f815f5d5b6c2e33754cedd4ca9780d8261"
