PACKAGECONFIG = "odirect dmeventd"
inherit nopackages
