FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-scripts-Fix-mock_icd_generator-syntax-warnings.patch file://0002-scripts-Port-codegen-script-from-VVL.patch"

