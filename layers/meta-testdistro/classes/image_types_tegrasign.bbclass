inherit image_types_tegra tegrasign
